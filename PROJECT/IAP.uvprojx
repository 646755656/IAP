# Keil uVision project IAP.uvprojx, settings and files
target IAP (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: IAP
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\..\IAP;..\SYSTEM
  memory RVCT4: ROM 0x8000000 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USR
    ../USER/: main.c iap.c work.c stmflash.c stm32f10x_it.c w25qxx.c spi.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
    ../: system_stm32f10x.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_wwdg.c
  group SYS
    ../SYSTEM/: delay.c timer.c watchdog.c sys.c uart.c
